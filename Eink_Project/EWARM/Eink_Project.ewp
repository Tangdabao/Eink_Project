# IAR project Eink_Project.ewp, settings and files
configuration Eink_Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32L011F4 ST STM32L011F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L011xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Eink_Project.hex
  ILINK.IlinkOutputFile: Eink_Project.out
  ILINK.IlinkIcfFile: stm32l011xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/APP
    ../Src/: cmd.c display.c osal.c Resource.c
  group Application/EWARM
    ./: startup_stm32l011xx.s
  group Application/User
    ../Src/: eink.c led.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c Timer.c usart.c w25q32.c
  group Doc
    ../: Readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
